# Keil uVision project uCOS-III_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: uCOS-III_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cm3gcc.ld Cm3RealView.scat CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h CySpc.c CySpc.h cytypes.h cyutils.c core_cm3_psoc5.h core_cm3.c core_cm3.h cyPm.c cyPm.h LCD_Disp.c LCD_Disp.h LCD_Disp_PM.c LCD_Disp_LCDPort.c LCD_Disp_LCDPort.h LCD_Disp_LCDPort_aliases.h LED.c LED.h LED_aliases.h cydevice.h cydevice_trm.h cydevicegnu.inc cydevicegnu_trm.inc cyfitter.h cyfitter_cfg.c cyfitter_cfg.h cyfittergnu.inc project.h cydevicerv.inc cydevicerv_trm.inc cyfitterrv.inc LED_Status.c LED_Status.h ProbeUART.c ProbeUART.h ProbeUART_PM.c ProbeUART_INT.c ProbeUART_TxISR.c ProbeUART_TxISR.h ProbeUART_RxISR.c ProbeUART_RxISR.h PB_2_aliases.h PB_2.c PB_2.h PB_3_aliases.h PB_3.c PB_3.h ProbeUART_Tx_aliases.h ProbeUART_Tx.c ProbeUART_Tx.h ProbeUART_Rx_aliases.h ProbeUART_Rx.c ProbeUART_Rx.h
target Release (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: as above
  output: uCOS-III_PSoC5lib (library)
