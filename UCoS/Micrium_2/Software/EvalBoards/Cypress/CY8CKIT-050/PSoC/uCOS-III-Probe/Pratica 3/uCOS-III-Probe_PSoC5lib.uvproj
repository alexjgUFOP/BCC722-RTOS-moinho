# Keil uVision project uCOS-III-Probe_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: uCOS-III-Probe_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h LED_Status.c LED_Status.h LED_aliases.h LED.c LED.h LCD_Disp.c LCD_Disp.h LCD_Disp_PM.c LCD_Disp_LCDPort_aliases.h LCD_Disp_LCDPort.c LCD_Disp_LCDPort.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h ProbeUART.c ProbeUART.h ProbeUART_PM.c ProbeUART_INT.c ProbeUART_TxISR.c ProbeUART_TxISR.h ProbeUART_RxISR.c ProbeUART_RxISR.h PB_2_aliases.h PB_2.c PB_2.h PB_3_aliases.h PB_3.c PB_3.h ProbeUART_Tx_aliases.h ProbeUART_Tx.c ProbeUART_Tx.h ProbeUART_Rx_aliases.h ProbeUART_Rx.c ProbeUART_Rx.h
target Release (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: as above
  output: uCOS-III-Probe_PSoC5lib (library)
